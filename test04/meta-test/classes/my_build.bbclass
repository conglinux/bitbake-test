addtask build
my_build_do_build () {

  echo "run my_build_do_build."

}

EXPORT_FUNCTIONS do_build
