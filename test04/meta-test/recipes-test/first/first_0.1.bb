DESCRIPTION = "This is the first recipe"
PR = "a1"
do_build () {
  echo "Hello World"
}
