DESCRIPTION = "This is the first recipe"
PN = "first"
PV = "0.1"
PR = "a1"

do_build () {
  echo "Hello World"
}
