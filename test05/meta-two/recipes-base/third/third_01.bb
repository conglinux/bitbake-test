
DESCRIPTION = "I am the third recipe"

PR = "a1"

inherit confbuild
